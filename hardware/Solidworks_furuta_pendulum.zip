STEP (ISO 10303-21) file: header records copied from the file, then geometry measured from it (millimetres).
FILE_DESCRIPTION(/* description */ ('EXPORT CONTROLLED - This document contains data whose export/transfer/disclosure is restricted by US law. Dissemination to non-US persons whether in the United States or abroad requires an export license or other authorization.'),/* implementation_level */ '2;1');
FILE_NAME(/* name */ 'magnet.stp',/* time_stamp */ '2026-04-21T19:42:20-04:00',/* author */ ('NX2412'),/* organization */ ('Northrop Grumman Mission Systems'),/* preprocessor_version */ 'ST-DEVELOPER v20',/* originating_system */ 'SIEMENS PLM Software NX2412.6001',/* authorisation */ 'Engineering Environment Development and Support');
FILE_SCHEMA (('AUTOMOTIVE_DESIGN { 1 0 10303 214 3 1 1 1 }'));
Length unit declared in the file: inch
Products named in the file (1): inverted_pendulum_nx_objects
Bounding box: 6 x 2.54 x 6 mm (x, y, z)
Volume: 71.8 mm3; surface area: 104.4 mm2
Topology: 1 solids, 1 shells, 3 faces, 3 edges, 2 vertices
Faces by surface type: plane 2, cylinder 1
Full cylindrical faces by diameter (mm): 6 x1
Entity records: 126 total; most frequent: DIRECTION 12, CARTESIAN_POINT 10, PROPERTY_DEFINITION 9, PROPERTY_DEFINITION_REPRESENTATION 8, REPRESENTATION 8, AXIS2_PLACEMENT_3D 6, MEASURE_REPRESENTATION_ITEM 4, EDGE_LOOP 4
