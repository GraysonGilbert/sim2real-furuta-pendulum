One B-rep face of a CAD part: STEP entity #97.
In plain terms, this planar face has unit normal (0, -1, 0).
Length unit declared in the file: inch
Its self-contained STEP definition (entity closure, numbers rounded to 3 decimals, lengths and spline knots to 5 decimals):
#81=PLANE('',#324);
#97=ADVANCED_FACE('',(#154,#155),#81,.T.);
#106=CIRCLE('',#300,0.27559);
#111=CIRCLE('',#309,0.16339);
#154=FACE_BOUND('',#194,.T.);
#155=FACE_BOUND('',#195,.T.);
#194=EDGE_LOOP('',(#240));
#195=EDGE_LOOP('',(#241));
#240=ORIENTED_EDGE('',*,*,#266,.T.);
#241=ORIENTED_EDGE('',*,*,#278,.F.);
#245=VERTEX_POINT('',#615);
#256=VERTEX_POINT('',#985);
#266=EDGE_CURVE('',#245,#245,#106,.T.);
#278=EDGE_CURVE('',#256,#256,#111,.T.);
#300=AXIS2_PLACEMENT_3D('',#614,#327,#328);
#309=AXIS2_PLACEMENT_3D('',#984,#345,#346);
#324=AXIS2_PLACEMENT_3D('',#1576,#375,#376);
#327=DIRECTION('',(0.,-1.,0.));
#328=DIRECTION('',(-0.032,0.,-0.999));
#345=DIRECTION('',(0.,-1.,0.));
#346=DIRECTION('',(-0.032,0.,-0.999));
#375=DIRECTION('',(0.,-1.,0.));
#376=DIRECTION('',(-0.032,0.,-0.999));
#614=CARTESIAN_POINT('',(0.02059,1.48193,1.32773));
#615=CARTESIAN_POINT('',(0.01173,1.48193,1.05228));
#984=CARTESIAN_POINT('',(0.02059,1.48193,1.32773));
#985=CARTESIAN_POINT('',(0.01534,1.48193,1.16443));
#1576=CARTESIAN_POINT('',(0.02059,1.48193,1.32773));
