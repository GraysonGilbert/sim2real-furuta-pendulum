One B-rep face of a CAD part: STEP entity #83.
In plain terms, this cylindrical face has radius 6.032 mm (diameter 12.064 mm), a full revolution.
Length unit declared in the file: inch
Its self-contained STEP definition (entity closure, numbers rounded to 3 decimals, lengths and spline knots to 5 decimals):
#83=ADVANCED_FACE('',(#98,#99),#94,.T.);
#94=CYLINDRICAL_SURFACE('',#189,0.23748);
#98=FACE_BOUND('',#116,.T.);
#99=FACE_BOUND('',#117,.T.);
#116=EDGE_LOOP('',(#136));
#117=EDGE_LOOP('',(#137));
#136=ORIENTED_EDGE('',*,*,#166,.F.);
#137=ORIENTED_EDGE('',*,*,#167,.T.);
#156=VERTEX_POINT('',#254);
#157=VERTEX_POINT('',#256);
#166=EDGE_CURVE('',#156,#156,#176,.T.);
#167=EDGE_CURVE('',#157,#157,#177,.T.);
#176=CIRCLE('',#187,0.23748);
#177=CIRCLE('',#188,0.23748);
#187=AXIS2_PLACEMENT_3D('',#253,#210,#211);
#188=AXIS2_PLACEMENT_3D('',#255,#212,#213);
#189=AXIS2_PLACEMENT_3D('',#257,#214,#215);
#210=DIRECTION('',(0.,-1.,0.));
#211=DIRECTION('',(1.,0.,0.));
#212=DIRECTION('',(0.,-1.,0.));
#213=DIRECTION('',(1.,0.,0.));
#214=DIRECTION('',(0.,1.,0.));
#215=DIRECTION('',(0.,0.,1.));
#253=CARTESIAN_POINT('',(0.02059,-0.74803,1.32773));
#254=CARTESIAN_POINT('',(0.25807,-0.74803,1.32773));
#255=CARTESIAN_POINT('',(0.02059,-0.49803,1.32773));
#256=CARTESIAN_POINT('',(0.25807,-0.49803,1.32773));
#257=CARTESIAN_POINT('',(0.02059,-0.74803,1.32773));
