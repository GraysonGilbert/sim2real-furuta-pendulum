STEP (ISO 10303-21) file: header records copied from the file, then geometry measured from it (millimetres).
FILE_DESCRIPTION(/* description */ ('EXPORT CONTROLLED - This document contains data whose export/transfer/disclosure is restricted by US law. Dissemination to non-US persons whether in the United States or abroad requires an export license or other authorization.'),/* implementation_level */ '2;1');
FILE_NAME(/* name */ 'new-rotating-base.stp',/* time_stamp */ '2026-04-21T19:41:28-04:00',/* author */ ('NX2412'),/* organization */ ('Northrop Grumman Mission Systems'),/* preprocessor_version */ 'ST-DEVELOPER v20',/* originating_system */ 'SIEMENS PLM Software NX2412.6001',/* authorisation */ 'Engineering Environment Development and Support');
FILE_SCHEMA (('AUTOMOTIVE_DESIGN { 1 0 10303 214 3 1 1 1 }'));
Length unit declared in the file: inch
Products named in the file (1): inverted_pendulum_nx_objects
Bounding box: 89.94 x 89.99 x 48 mm (x, y, z)
Volume: 89993.8 mm3; surface area: 25065.5 mm2
Topology: 1 solids, 1 shells, 110 faces, 279 edges, 177 vertices
Faces by surface type: plane 41, bspline 28, cylinder 27, cone 14
Full cylindrical faces by diameter (mm): 2.5 x4, 3.4 x2, 7.3 x2, 8.25 x1, 18 x1, 22.3 x2, 90 x1
Entity records: 4704 total; most frequent: CARTESIAN_POINT 2349, ORIENTED_EDGE 484, DIRECTION 381, EDGE_CURVE 242, VERTEX_POINT 168, EDGE_LOOP 152, AXIS2_PLACEMENT_3D 149, ADVANCED_FACE 110
