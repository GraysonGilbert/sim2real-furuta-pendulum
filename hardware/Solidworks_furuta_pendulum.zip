One B-rep face of a CAD part: STEP entity #331.
In plain terms, this planar face has unit normal (-1, 0, 0).
Length unit declared in the file: inch
Its self-contained STEP definition (entity closure, numbers rounded to 3 decimals, lengths and spline knots to 5 decimals):
#331=ADVANCED_FACE('',(#466),#421,.F.);
#421=PLANE('',#1899);
#466=FACE_OUTER_BOUND('',#581,.T.);
#581=EDGE_LOOP('',(#937,#938,#939,#940));
#697=B_SPLINE_CURVE_WITH_KNOTS('',3,(#3124,#3125,#3126,#3127),
 .UNSPECIFIED.,.F.,.F.,(4,4),(0.,1.),.UNSPECIFIED.);
#698=B_SPLINE_CURVE_WITH_KNOTS('',3,(#3132,#3133,#3134,#3135),
 .UNSPECIFIED.,.F.,.F.,(4,4),(0.,1.),.UNSPECIFIED.);
#937=ORIENTED_EDGE('',*,*,#1525,.T.);
#938=ORIENTED_EDGE('',*,*,#1526,.T.);
#939=ORIENTED_EDGE('',*,*,#1527,.T.);
#940=ORIENTED_EDGE('',*,*,#1528,.T.);
#1337=VERTEX_POINT('',#3128);
#1338=VERTEX_POINT('',#3129);
#1339=VERTEX_POINT('',#3131);
#1340=VERTEX_POINT('',#3136);
#1525=EDGE_CURVE('',#1337,#1338,#697,.T.);
#1526=EDGE_CURVE('',#1338,#1339,#1704,.T.);
#1527=EDGE_CURVE('',#1339,#1340,#698,.T.);
#1528=EDGE_CURVE('',#1340,#1337,#1705,.T.);
#1704=LINE('',#3130,#1787);
#1705=LINE('',#3137,#1788);
#1787=VECTOR('',#2167,1.);
#1788=VECTOR('',#2168,1.);
#1899=AXIS2_PLACEMENT_3D('',#3138,#2169,#2170);
#2167=DIRECTION('',(0.,0.,1.));
#2168=DIRECTION('',(0.,0.,-1.));
#2169=DIRECTION('',(1.,0.,0.));
#2170=DIRECTION('',(0.,1.,0.));
#3124=CARTESIAN_POINT('',(-0.76681,1.48544,0.84348));
#3125=CARTESIAN_POINT('',(-0.76681,1.26942,0.84348));
#3126=CARTESIAN_POINT('',(-0.76681,1.05341,0.84348));
#3127=CARTESIAN_POINT('',(-0.76681,0.8374,0.84348));
#3128=CARTESIAN_POINT('',(-0.76681,1.48544,0.84348));
#3129=CARTESIAN_POINT('',(-0.76681,0.8374,0.84348));
#3130=CARTESIAN_POINT('',(-0.76681,0.8374,0.34348));
#3131=CARTESIAN_POINT('',(-0.76681,0.8374,1.41828));
#3132=CARTESIAN_POINT('',(-0.76681,0.8374,1.41828));
#3133=CARTESIAN_POINT('',(-0.76681,1.05341,1.41828));
#3134=CARTESIAN_POINT('',(-0.76681,1.26942,1.41828));
#3135=CARTESIAN_POINT('',(-0.76681,1.48544,1.41828));
#3136=CARTESIAN_POINT('',(-0.76681,1.48544,1.41828));
#3137=CARTESIAN_POINT('',(-0.76681,1.48544,0.84348));
#3138=CARTESIAN_POINT('',(-0.76681,1.53544,0.34348));
