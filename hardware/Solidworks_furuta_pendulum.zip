One B-rep face of a CAD part: STEP entity #79.
In plain terms, this planar face has unit normal (0, -1, 0).
Length unit declared in the file: inch
Its self-contained STEP definition (entity closure, numbers rounded to 3 decimals, lengths and spline knots to 5 decimals):
#74=PLANE('',#102);
#76=FACE_OUTER_BOUND('',#86,.T.);
#79=ADVANCED_FACE('',(#76),#74,.T.);
#86=EDGE_LOOP('',(#90));
#90=ORIENTED_EDGE('',*,*,#94,.T.);
#92=VERTEX_POINT('',#118);
#94=EDGE_CURVE('',#92,#92,#96,.T.);
#96=CIRCLE('',#99,0.11811);
#99=AXIS2_PLACEMENT_3D('',#117,#106,#107);
#102=AXIS2_PLACEMENT_3D('',#122,#112,#113);
#106=DIRECTION('',(0.,-1.,0.));
#107=DIRECTION('',(1.,0.,0.));
#112=DIRECTION('',(0.,-1.,0.));
#113=DIRECTION('',(1.,0.,0.));
#117=CARTESIAN_POINT('',(0.02059,-1.02303,1.32773));
#118=CARTESIAN_POINT('',(0.1387,-1.02303,1.32773));
#122=CARTESIAN_POINT('',(0.02059,-1.02303,1.32773));
