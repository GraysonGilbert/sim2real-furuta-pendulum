STEP (ISO 10303-21) file: header records copied from the file, then geometry measured from it (millimetres).
FILE_DESCRIPTION(/* description */ ('EXPORT CONTROLLED - This document contains data whose export/transfer/disclosure is restricted by US law. Dissemination to non-US persons whether in the United States or abroad requires an export license or other authorization.'),/* implementation_level */ '2;1');
FILE_NAME(/* name */ 'new-rod-holder.stp',/* time_stamp */ '2026-04-21T19:40:59-04:00',/* author */ ('NX2412'),/* organization */ ('Northrop Grumman Mission Systems'),/* preprocessor_version */ 'ST-DEVELOPER v20',/* originating_system */ 'SIEMENS PLM Software NX2412.6001',/* authorisation */ 'Engineering Environment Development and Support');
FILE_SCHEMA (('AUTOMOTIVE_DESIGN { 1 0 10303 214 3 1 1 1 }'));
Length unit declared in the file: inch
Products named in the file (1): inverted_pendulum_nx_objects
Bounding box: 20.04 x 59.21 x 43.25 mm (x, y, z)
Surface area: 7410.9 mm2 (no closed solid volume)
Topology: 0 solids, 1 shells, 16 faces, 58 edges, 39 vertices
Faces by surface type: cylinder 8, cone 4, plane 3, bspline 1
Full cylindrical faces by diameter (mm): 1.778 x4, 8.3 x1, 13 x1, 14 x1, 18.7 x1
Entity records: 1579 total; most frequent: CARTESIAN_POINT 1202, DIRECTION 52, ORIENTED_EDGE 46, FACE_BOUND 40, EDGE_LOOP 40, AXIS2_PLACEMENT_3D 26, EDGE_CURVE 23, VERTEX_POINT 21
