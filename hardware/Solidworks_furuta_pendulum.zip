STEP (ISO 10303-21) file: header records copied from the file, then geometry measured from it (millimetres).
FILE_DESCRIPTION(/* description */ ('EXPORT CONTROLLED - This document contains data whose export/transfer/disclosure is restricted by US law. Dissemination to non-US persons whether in the United States or abroad requires an export license or other authorization.'),/* implementation_level */ '2;1');
FILE_NAME(/* name */ 'magnet-cap.stp',/* time_stamp */ '2026-04-21T19:42:07-04:00',/* author */ ('NX2412'),/* organization */ ('Northrop Grumman Mission Systems'),/* preprocessor_version */ 'ST-DEVELOPER v20',/* originating_system */ 'SIEMENS PLM Software NX2412.6001',/* authorisation */ 'Engineering Environment Development and Support');
FILE_SCHEMA (('AUTOMOTIVE_DESIGN { 1 0 10303 214 3 1 1 1 }'));
Length unit declared in the file: inch
Products named in the file (1): inverted_pendulum_nx_objects
Bounding box: 12.06 x 12.06 x 12.06 mm (x, y, z)
Volume: 816 mm3; surface area: 818.2 mm2
Topology: 1 solids, 1 shells, 11 faces, 18 edges, 12 vertices
Faces by surface type: plane 5, cylinder 4, cone 2
Full cylindrical faces by diameter (mm): 6 x1, 8 x1, 10.064 x1, 12.064 x1
Entity records: 286 total; most frequent: DIRECTION 44, CARTESIAN_POINT 34, AXIS2_PLACEMENT_3D 22, EDGE_LOOP 20, ORIENTED_EDGE 20, FACE_BOUND 18, ADVANCED_FACE 11, VERTEX_POINT 10
